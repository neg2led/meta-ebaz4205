HDF_PATH = "github.com/neg2led/ebaz4205_xsa.git;branch=rel-v2020.2"
HDF_NAME = "ebaz4205_top.xsa"

HDF_MACHINE = ""

SRCREV = "ae46e939bb43424bba9435524f5aee263a23384d"
